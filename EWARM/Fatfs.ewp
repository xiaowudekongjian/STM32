# IAR project Fatfs.ewp, settings and files
configuration Fatfs (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 5
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Core/Inc; ../FATFS/Target; ../FATFS/App; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FatFs/src/drivers; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Fatfs.hex
  ILINK.IlinkOutputFile: Fatfs.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c sdio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_mmc.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
